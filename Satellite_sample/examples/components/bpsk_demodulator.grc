options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: bpsk_demodulator
    output_language: python
    title: BPSK demodulator component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '20000'
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '10000'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\user\Documents\sample_sounds\gr-satellites\satellite-recordings\lilacsat1.wav
    repeat: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '20000'
    srate: '9600'
    style1: '0'
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '9600'
    differential: 'False'
    f_offset: '12000'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_head_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [blocks_wavfile_source_0, '0', satellites_bpsk_demodulator_0, '0']
- [satellites_bpsk_demodulator_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
